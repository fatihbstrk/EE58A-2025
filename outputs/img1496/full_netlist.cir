* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XBJT_pin3 NET11 dummy_subckt
XCurrent_Source_pin0 NET11 dummy_subckt
XAC_Source_pin0 NET11 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XAC_Source_pin1 NET17 dummy_subckt
XCurrent_Source_pin3 NET19 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
