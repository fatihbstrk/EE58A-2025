* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XResistor_pin0 NET6 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XGround_pin0 NET15 dummy_subckt
.end
