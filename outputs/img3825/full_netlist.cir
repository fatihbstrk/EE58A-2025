* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XCurrent_Source_pin0 NET10 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
