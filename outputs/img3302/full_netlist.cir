* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin1 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XDiode_pin0 NET5 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XDiode_pin1 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCapacitor_pin1 NET14 dummy_subckt
.end
