* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin3 NET7 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XResistor_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XResistor_pin0 NET18 dummy_subckt
.end
