* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin2 NET5 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XCurrent_Source_pin0 NET24 dummy_subckt
XCurrent_Source_pin1 NET25 dummy_subckt
.end
