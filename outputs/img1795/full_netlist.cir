* Auto-generated SPICE netlist
.include technology_models.lib
XGround_pin0 NET4 dummy_subckt
XGround_pin2 NET24 dummy_subckt
XGround_pin3 NET25 dummy_subckt
XGround_pin1 NET26 dummy_subckt
XMOSFET_pin0 NET27 dummy_subckt
XMOSFET_pin0 NET28 dummy_subckt
XMOSFET_pin3 NET33 dummy_subckt
XMOSFET_pin2 NET35 dummy_subckt
XMOSFET_pin3 NET36 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XGround_pin3 NET41 dummy_subckt
XCurrent_Source_pin0 NET43 dummy_subckt
XMOSFET_pin1 NET45 dummy_subckt
XMOSFET_pin1 NET46 dummy_subckt
XGround_pin2 NET46 dummy_subckt
XCurrent_Source_pin2 NET49 dummy_subckt
XCurrent_Source_pin3 NET50 dummy_subckt
XGround_pin3 NET50 dummy_subckt
XGround_pin1 NET51 dummy_subckt
XCurrent_Source_pin1 NET53 dummy_subckt
XGround_pin0 NET53 dummy_subckt
XGround_pin2 NET55 dummy_subckt
XGround_pin1 NET56 dummy_subckt
.end
