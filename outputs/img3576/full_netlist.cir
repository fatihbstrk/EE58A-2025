* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XResistor_pin0 NET2 dummy_subckt
XBJT_pin2 NET12 dummy_subckt
XResistor_pin1 NET14 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XResistor_pin0 NET19 dummy_subckt
XBJT_pin2 NET21 dummy_subckt
XBJT_pin3 NET23 dummy_subckt
XDC_Source_pin0 NET23 dummy_subckt
XResistor_pin0 NET26 dummy_subckt
XDC_Source_pin3 NET34 dummy_subckt
XDC_Source_pin1 NET36 dummy_subckt
XResistor_pin1 NET36 dummy_subckt
XResistor_pin1 NET36 dummy_subckt
.end
