* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XDC_Source_pin0 NET3 dummy_subckt
XDC_Source_pin3 NET4 dummy_subckt
XCapacitor_pin0 NET6 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XDC_Source_pin1 NET7 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin1 NET20 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XCapacitor_pin2 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCapacitor_pin1 NET23 dummy_subckt
XCapacitor_pin0 NET24 dummy_subckt
XCapacitor_pin0 NET25 dummy_subckt
XCapacitor_pin3 NET26 dummy_subckt
XMOSFET_pin3 NET28 dummy_subckt
XMOSFET_pin2 NET29 dummy_subckt
XCapacitor_pin3 NET31 dummy_subckt
XMOSFET_pin2 NET32 dummy_subckt
XMOSFET_pin3 NET33 dummy_subckt
XCapacitor_pin1 NET36 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XCapacitor_pin1 NET37 dummy_subckt
XGround_pin0 NET37 dummy_subckt
.end
