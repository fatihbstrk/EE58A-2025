* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XBJT_pin3 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XResistor_pin2 NET7 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XBJT_pin2 NET26 dummy_subckt
XBJT_pin3 NET27 dummy_subckt
XGround_pin0 NET35 dummy_subckt
XBJT_pin3 NET40 dummy_subckt
.end
