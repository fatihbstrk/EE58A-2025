* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XCapacitor_pin0 NET3 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XCapacitor_pin1 NET7 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XAC_Source_pin1 NET8 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCapacitor_pin1 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
.end
