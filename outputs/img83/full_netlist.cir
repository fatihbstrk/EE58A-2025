* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XBJT_pin3 NET14 dummy_subckt
XDC_Source_pin0 NET14 dummy_subckt
XResistor_pin0 NET20 dummy_subckt
XResistor_pin0 NET21 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XDC_Source_pin1 NET23 dummy_subckt
XResistor_pin1 NET30 dummy_subckt
XResistor_pin1 NET30 dummy_subckt
XCurrent_Source_pin0 NET30 dummy_subckt
XCurrent_Source_pin0 NET30 dummy_subckt
XGround_pin0 NET31 dummy_subckt
XCurrent_Source_pin1 NET31 dummy_subckt
XCurrent_Source_pin1 NET31 dummy_subckt
XGround_pin1 NET32 dummy_subckt
.end
