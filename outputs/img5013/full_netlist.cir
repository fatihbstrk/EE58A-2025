* Auto-generated SPICE netlist
.include technology_models.lib
XAC_Source_pin0 NET1 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XAC_Source_pin1 NET6 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XGround_pin0 NET7 dummy_subckt
.end
