* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XBJT_pin2 NET5 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XBJT_pin2 NET10 dummy_subckt
XBJT_pin3 NET11 dummy_subckt
XBJT_pin3 NET13 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XBJT_pin2 NET23 dummy_subckt
XBJT_pin3 NET24 dummy_subckt
XGround_pin0 NET26 dummy_subckt
.end
