* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET7 dummy_subckt
XBJT_pin3 NET7 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
.end
