* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET9 dummy_subckt
.end
