* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET56 dummy_subckt
XMOSFET_pin2 NET58 dummy_subckt
XMOSFET_pin3 NET59 dummy_subckt
XMOSFET_pin3 NET60 dummy_subckt
XMOSFET_pin1 NET61 dummy_subckt
.end
