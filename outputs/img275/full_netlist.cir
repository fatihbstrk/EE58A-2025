* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin1 NET10 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XCapacitor_pin1 NET13 dummy_subckt
XCapacitor_pin0 NET17 dummy_subckt
XCapacitor_pin2 NET21 dummy_subckt
XCapacitor_pin3 NET23 dummy_subckt
XCapacitor_pin2 NET23 dummy_subckt
XCapacitor_pin3 NET23 dummy_subckt
XCapacitor_pin2 NET25 dummy_subckt
XCapacitor_pin2 NET25 dummy_subckt
XCapacitor_pin2 NET25 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XCapacitor_pin1 NET31 dummy_subckt
XCapacitor_pin0 NET32 dummy_subckt
.end
