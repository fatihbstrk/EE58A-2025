* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XAC_Source_pin0 NET20 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XAC_Source_pin1 NET22 dummy_subckt
.end
