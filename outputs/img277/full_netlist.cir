* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCurrent_Source_pin3 NET5 dummy_subckt
XCurrent_Source_pin3 NET6 dummy_subckt
XCapacitor_pin0 NET8 dummy_subckt
XCapacitor_pin0 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCapacitor_pin3 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XMOSFET_pin3 NET18 dummy_subckt
XCapacitor_pin1 NET18 dummy_subckt
XCapacitor_pin2 NET20 dummy_subckt
XCapacitor_pin1 NET20 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
.end
