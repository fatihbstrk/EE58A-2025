* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin0 NET4 dummy_subckt
XCapacitor_pin1 NET7 dummy_subckt
XGround_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XGround_pin0 NET11 dummy_subckt
.end
