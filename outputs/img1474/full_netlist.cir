* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET7 dummy_subckt
XCurrent_Source_pin1 NET18 dummy_subckt
XGround_pin1 NET18 dummy_subckt
XMOSFET_pin3 NET18 dummy_subckt
XMOSFET_pin3 NET23 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XGround_pin0 NET29 dummy_subckt
XGround_pin0 NET30 dummy_subckt
.end
