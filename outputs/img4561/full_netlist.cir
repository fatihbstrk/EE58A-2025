* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XMOSFET_pin3 NET21 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
