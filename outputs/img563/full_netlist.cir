* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XResistor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XBattery_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XResistor_pin2 NET8 dummy_subckt
XResistor_pin3 NET9 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XMOSFET_pin3 NET25 dummy_subckt
XMOSFET_pin2 NET28 dummy_subckt
.end
