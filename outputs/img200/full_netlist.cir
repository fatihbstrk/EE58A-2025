* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET4 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XResistor_pin0 NET12 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XCapacitor_pin3 NET18 dummy_subckt
XResistor_pin1 NET23 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XMOSFET_pin3 NET27 dummy_subckt
XMOSFET_pin2 NET28 dummy_subckt
.end
