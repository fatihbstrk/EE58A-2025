* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin3 NET7 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XResistor_pin0 NET12 dummy_subckt
XDiode_pin3 NET12 dummy_subckt
XResistor_pin1 NET16 dummy_subckt
XDiode_pin0 NET16 dummy_subckt
XDiode_pin2 NET16 dummy_subckt
XDiode_pin1 NET29 dummy_subckt
XDiode_pin0 NET29 dummy_subckt
XResistor_pin1 NET30 dummy_subckt
XBJT_pin2 NET30 dummy_subckt
XBJT_pin3 NET32 dummy_subckt
XDiode_pin1 NET36 dummy_subckt
XDiode_pin0 NET36 dummy_subckt
XBJT_pin2 NET38 dummy_subckt
XBJT_pin3 NET38 dummy_subckt
XResistor_pin0 NET38 dummy_subckt
XResistor_pin1 NET39 dummy_subckt
XGround_pin0 NET39 dummy_subckt
XDiode_pin1 NET39 dummy_subckt
XBJT_pin2 NET41 dummy_subckt
.end
