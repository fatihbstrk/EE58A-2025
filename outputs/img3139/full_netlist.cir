* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XDC_Source_pin0 NET4 dummy_subckt
XResistor_pin2 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
XResistor_pin3 NET10 dummy_subckt
XDC_Source_pin1 NET10 dummy_subckt
XResistor_pin2 NET11 dummy_subckt
XResistor_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XCapacitor_pin2 NET20 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCapacitor_pin2 NET24 dummy_subckt
XGround_pin0 NET24 dummy_subckt
XCapacitor_pin3 NET25 dummy_subckt
XCapacitor_pin3 NET25 dummy_subckt
XCurrent_Source_pin0 NET25 dummy_subckt
XMOSFET_pin2 NET26 dummy_subckt
XCapacitor_pin3 NET26 dummy_subckt
XGround_pin1 NET26 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XGround_pin0 NET35 dummy_subckt
XCurrent_Source_pin1 NET35 dummy_subckt
XMOSFET_pin3 NET36 dummy_subckt
XCapacitor_pin2 NET38 dummy_subckt
XCapacitor_pin2 NET38 dummy_subckt
XCapacitor_pin3 NET39 dummy_subckt
XCurrent_Source_pin0 NET44 dummy_subckt
XCapacitor_pin3 NET50 dummy_subckt
XGround_pin0 NET52 dummy_subckt
XGround_pin0 NET53 dummy_subckt
XCurrent_Source_pin1 NET53 dummy_subckt
XGround_pin0 NET56 dummy_subckt
.end
