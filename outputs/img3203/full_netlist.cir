* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XGround_pin0 NET7 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XResistor_pin0 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XGround_pin0 NET11 dummy_subckt
.end
