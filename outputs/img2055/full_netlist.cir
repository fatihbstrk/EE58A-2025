* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
