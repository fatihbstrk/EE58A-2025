* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET11 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XBJT_pin2 NET17 dummy_subckt
XBJT_pin2 NET21 dummy_subckt
.end
