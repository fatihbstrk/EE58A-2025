* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin0 NET6 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XMOSFET_pin1 NET16 dummy_subckt
XCapacitor_pin1 NET17 dummy_subckt
XResistor_pin0 NET19 dummy_subckt
XResistor_pin2 NET26 dummy_subckt
XCapacitor_pin0 NET27 dummy_subckt
XMOSFET_pin0 NET27 dummy_subckt
XMOSFET_pin0 NET28 dummy_subckt
XCapacitor_pin3 NET31 dummy_subckt
XResistor_pin1 NET31 dummy_subckt
XResistor_pin0 NET31 dummy_subckt
XCapacitor_pin3 NET31 dummy_subckt
XMOSFET_pin3 NET35 dummy_subckt
XCapacitor_pin2 NET37 dummy_subckt
XMOSFET_pin2 NET37 dummy_subckt
XResistor_pin2 NET46 dummy_subckt
XCurrent_Source_pin0 NET49 dummy_subckt
XCapacitor_pin1 NET52 dummy_subckt
XMOSFET_pin1 NET52 dummy_subckt
XCapacitor_pin1 NET53 dummy_subckt
XCapacitor_pin1 NET53 dummy_subckt
XGround_pin3 NET55 dummy_subckt
XCurrent_Source_pin3 NET55 dummy_subckt
XResistor_pin1 NET56 dummy_subckt
XGround_pin0 NET56 dummy_subckt
XGround_pin3 NET57 dummy_subckt
XCurrent_Source_pin2 NET58 dummy_subckt
XGround_pin2 NET59 dummy_subckt
XGround_pin2 NET61 dummy_subckt
XGround_pin0 NET62 dummy_subckt
XCurrent_Source_pin1 NET62 dummy_subckt
XGround_pin1 NET63 dummy_subckt
XGround_pin1 NET64 dummy_subckt
.end
