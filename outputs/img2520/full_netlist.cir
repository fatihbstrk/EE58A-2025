* Auto-generated SPICE netlist
.include technology_models.lib
XGround_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XGround_pin0 NET7 dummy_subckt
.end
