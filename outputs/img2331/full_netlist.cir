* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET1 dummy_subckt
XCapacitor_pin1 NET1 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XCapacitor_pin0 NET19 dummy_subckt
.end
