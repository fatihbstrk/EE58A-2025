* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET1 dummy_subckt
XBJT_pin3 NET1 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET5 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XBJT_pin3 NET12 dummy_subckt
XResistor_pin3 NET15 dummy_subckt
XCurrent_Source_pin0 NET15 dummy_subckt
XResistor_pin2 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XCurrent_Source_pin1 NET23 dummy_subckt
XCurrent_Source_pin1 NET23 dummy_subckt
.end
