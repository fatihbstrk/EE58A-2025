* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET9 dummy_subckt
XMOSFET_pin0 NET9 dummy_subckt
XGround_pin0 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
