* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET2 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCurrent_Source_pin0 NET5 dummy_subckt
XCurrent_Source_pin0 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
.end
