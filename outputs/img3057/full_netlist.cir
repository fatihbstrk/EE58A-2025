* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCurrent_Source_pin0 NET9 dummy_subckt
XCurrent_Source_pin0 NET10 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
.end
