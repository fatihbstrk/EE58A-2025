* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XCurrent_Source_pin0 NET12 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
.end
