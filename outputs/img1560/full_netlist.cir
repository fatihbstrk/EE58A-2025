* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XResistor_pin0 NET10 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XResistor_pin1 NET22 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XCurrent_Source_pin0 NET26 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XCurrent_Source_pin1 NET30 dummy_subckt
XGround_pin0 NET30 dummy_subckt
.end
