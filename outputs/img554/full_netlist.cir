* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET9 dummy_subckt
XCapacitor_pin0 NET13 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XCapacitor_pin1 NET23 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XMOSFET_pin2 NET25 dummy_subckt
XGround_pin0 NET27 dummy_subckt
.end
