* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET1 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XCurrent_Source_pin0 NET15 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
