* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XBattery_pin0 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
