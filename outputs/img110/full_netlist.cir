* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XBJT_pin3 NET14 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XResistor_pin0 NET17 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XResistor_pin1 NET21 dummy_subckt
.end
