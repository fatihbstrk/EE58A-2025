* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XBattery_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XMOSFET_pin3 NET19 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XCapacitor_pin2 NET20 dummy_subckt
XCapacitor_pin1 NET22 dummy_subckt
XResistor_pin1 NET25 dummy_subckt
XBJT_pin2 NET26 dummy_subckt
XBJT_pin2 NET27 dummy_subckt
XBJT_pin3 NET27 dummy_subckt
XGround_pin0 NET27 dummy_subckt
.end
