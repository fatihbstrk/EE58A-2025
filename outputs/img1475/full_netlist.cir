* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XBJT_pin2 NET4 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XBJT_pin3 NET7 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XGround_pin0 NET11 dummy_subckt
.end
