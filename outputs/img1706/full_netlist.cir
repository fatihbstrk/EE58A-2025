* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XCurrent_Source_pin0 NET9 dummy_subckt
XCapacitor_pin0 NET9 dummy_subckt
XResistor_pin0 NET9 dummy_subckt
XAC_Source_pin0 NET9 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XAC_Source_pin1 NET16 dummy_subckt
XCurrent_Source_pin1 NET20 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XCapacitor_pin1 NET22 dummy_subckt
XGround_pin0 NET22 dummy_subckt
.end
