* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin2 NET4 dummy_subckt
XBJT_pin2 NET4 dummy_subckt
XBJT_pin3 NET4 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XResistor_pin2 NET7 dummy_subckt
XResistor_pin3 NET8 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XDC_Source_pin0 NET20 dummy_subckt
XDC_Source_pin1 NET23 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
