* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
XGround_pin0 NET16 dummy_subckt
.end
