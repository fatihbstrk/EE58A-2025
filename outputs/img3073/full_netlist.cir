* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin3 NET9 dummy_subckt
XResistor_pin2 NET12 dummy_subckt
XResistor_pin3 NET13 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XResistor_pin3 NET20 dummy_subckt
XResistor_pin2 NET20 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XCapacitor_pin2 NET20 dummy_subckt
XAC_Source_pin0 NET20 dummy_subckt
XAC_Source_pin0 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XAC_Source_pin1 NET23 dummy_subckt
XAC_Source_pin1 NET23 dummy_subckt
.end
