* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCurrent_Source_pin1 NET3 dummy_subckt
XMOSFET_pin2 NET44 dummy_subckt
XMOSFET_pin3 NET44 dummy_subckt
XGround_pin0 NET50 dummy_subckt
XGround_pin0 NET51 dummy_subckt
XGround_pin0 NET52 dummy_subckt
.end
