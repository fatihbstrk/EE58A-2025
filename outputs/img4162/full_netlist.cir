* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XResistor_pin0 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XResistor_pin0 NET19 dummy_subckt
XResistor_pin1 NET22 dummy_subckt
XMOSFET_pin3 NET22 dummy_subckt
XResistor_pin1 NET25 dummy_subckt
XGround_pin0 NET25 dummy_subckt
XMOSFET_pin2 NET26 dummy_subckt
.end
