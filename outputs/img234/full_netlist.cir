* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCurrent_Source_pin1 NET3 dummy_subckt
XGround_pin0 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XCurrent_Source_pin3 NET9 dummy_subckt
XGround_pin0 NET12 dummy_subckt
XCapacitor_pin0 NET13 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin1 NET23 dummy_subckt
XGround_pin0 NET25 dummy_subckt
XGround_pin0 NET27 dummy_subckt
XCapacitor_pin2 NET29 dummy_subckt
XMOSFET_pin3 NET30 dummy_subckt
XMOSFET_pin3 NET31 dummy_subckt
XGround_pin0 NET33 dummy_subckt
.end
