* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XCapacitor_pin0 NET14 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XBJT_pin2 NET16 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XBJT_pin3 NET23 dummy_subckt
.end
