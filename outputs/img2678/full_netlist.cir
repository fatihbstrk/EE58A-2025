* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XGround_pin0 NET15 dummy_subckt
.end
