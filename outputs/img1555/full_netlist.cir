* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET5 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XBJT_pin3 NET19 dummy_subckt
XCurrent_Source_pin0 NET24 dummy_subckt
XCurrent_Source_pin1 NET28 dummy_subckt
XGround_pin0 NET28 dummy_subckt
.end
