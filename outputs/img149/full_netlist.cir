* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XGround_pin0 NET13 dummy_subckt
.end
