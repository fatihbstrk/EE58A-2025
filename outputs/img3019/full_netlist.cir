* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XResistor_pin3 NET12 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XResistor_pin2 NET13 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XResistor_pin2 NET20 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XResistor_pin3 NET21 dummy_subckt
XCapacitor_pin2 NET21 dummy_subckt
XCurrent_Source_pin0 NET23 dummy_subckt
XGround_pin0 NET24 dummy_subckt
XCurrent_Source_pin1 NET24 dummy_subckt
.end
