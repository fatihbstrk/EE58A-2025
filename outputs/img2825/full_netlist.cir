* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET1 dummy_subckt
XCapacitor_pin0 NET1 dummy_subckt
XResistor_pin2 NET4 dummy_subckt
XCapacitor_pin1 NET4 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XCapacitor_pin1 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XResistor_pin3 NET6 dummy_subckt
XResistor_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XAC_Source_pin0 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XAC_Source_pin1 NET10 dummy_subckt
.end
