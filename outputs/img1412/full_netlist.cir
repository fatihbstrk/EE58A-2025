* Auto-generated SPICE netlist
.include technology_models.lib
.end
