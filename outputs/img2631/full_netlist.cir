* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
.end
