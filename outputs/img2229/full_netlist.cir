* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET14 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XDC_Source_pin0 NET19 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XDC_Source_pin1 NET22 dummy_subckt
.end
