* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XAC_Source_pin0 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XAC_Source_pin1 NET8 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin0 NET17 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCapacitor_pin2 NET25 dummy_subckt
XMOSFET_pin3 NET26 dummy_subckt
.end
