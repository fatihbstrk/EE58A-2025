* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XMOSFET_pin3 NET21 dummy_subckt
XMOSFET_pin3 NET22 dummy_subckt
XMOSFET_pin2 NET22 dummy_subckt
XAC_Source_pin0 NET22 dummy_subckt
XResistor_pin0 NET26 dummy_subckt
XCurrent_Source_pin0 NET26 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XAC_Source_pin1 NET28 dummy_subckt
XResistor_pin1 NET32 dummy_subckt
XCurrent_Source_pin1 NET32 dummy_subckt
XGround_pin0 NET32 dummy_subckt
.end
