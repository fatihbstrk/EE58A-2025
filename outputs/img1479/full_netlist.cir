* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET1 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XGround_pin1 NET13 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XCapacitor_pin2 NET13 dummy_subckt
XCapacitor_pin2 NET13 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
