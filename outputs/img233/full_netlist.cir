* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XGround_pin0 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XResistor_pin3 NET6 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XGround_pin0 NET12 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XMOSFET_pin3 NET23 dummy_subckt
XMOSFET_pin2 NET24 dummy_subckt
XGround_pin0 NET26 dummy_subckt
.end
