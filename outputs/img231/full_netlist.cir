* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET4 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XGround_pin0 NET11 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XCapacitor_pin2 NET22 dummy_subckt
XCapacitor_pin2 NET22 dummy_subckt
.end
