* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin0 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin1 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XDC_Source_pin0 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XDC_Source_pin1 NET10 dummy_subckt
XGround_pin0 NET11 dummy_subckt
XCurrent_Source_pin1 NET11 dummy_subckt
.end
