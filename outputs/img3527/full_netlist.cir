* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XBJT_pin2 NET10 dummy_subckt
XBJT_pin1 NET10 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XBJT_pin3 NET13 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XDC_Source_pin1 NET14 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XDC_Source_pin0 NET17 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XResistor_pin0 NET19 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XCapacitor_pin2 NET22 dummy_subckt
XGround_pin0 NET28 dummy_subckt
.end
