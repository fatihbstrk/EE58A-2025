* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET3 dummy_subckt
XResistor_pin0 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XResistor_pin1 NET25 dummy_subckt
XCapacitor_pin3 NET25 dummy_subckt
XCapacitor_pin3 NET25 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XGround_pin0 NET31 dummy_subckt
.end
