* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XResistor_pin0 NET2 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
.end
