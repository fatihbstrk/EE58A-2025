* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
