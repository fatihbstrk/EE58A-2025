* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XResistor_pin2 NET14 dummy_subckt
XCurrent_Source_pin0 NET14 dummy_subckt
XResistor_pin3 NET15 dummy_subckt
XCurrent_Source_pin0 NET15 dummy_subckt
XCurrent_Source_pin1 NET18 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
