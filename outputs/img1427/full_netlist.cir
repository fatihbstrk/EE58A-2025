* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin1 NET2 dummy_subckt
.end
