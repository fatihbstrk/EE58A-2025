* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin0 NET11 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
XMOSFET_pin3 NET14 dummy_subckt
XCapacitor_pin1 NET15 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XMOSFET_pin1 NET18 dummy_subckt
XDC_Source_pin0 NET23 dummy_subckt
XCapacitor_pin3 NET23 dummy_subckt
XAC_Source_pin0 NET23 dummy_subckt
XCapacitor_pin3 NET23 dummy_subckt
XGround_pin0 NET24 dummy_subckt
XDC_Source_pin1 NET24 dummy_subckt
XAC_Source_pin1 NET24 dummy_subckt
.end
