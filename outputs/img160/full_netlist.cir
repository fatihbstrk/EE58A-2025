* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin3 NET3 dummy_subckt
XBJT_pin2 NET3 dummy_subckt
XBJT_pin2 NET4 dummy_subckt
XBJT_pin2 NET5 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XBJT_pin3 NET15 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XResistor_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XResistor_pin0 NET18 dummy_subckt
XResistor_pin3 NET21 dummy_subckt
XResistor_pin2 NET22 dummy_subckt
.end
