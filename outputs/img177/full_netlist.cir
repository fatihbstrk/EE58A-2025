* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin0 NET4 dummy_subckt
XBJT_pin2 NET5 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XBJT_pin2 NET21 dummy_subckt
XBJT_pin3 NET22 dummy_subckt
XBattery_pin0 NET22 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XBattery_pin3 NET26 dummy_subckt
XBattery_pin1 NET30 dummy_subckt
XBJT_pin3 NET31 dummy_subckt
XBJT_pin2 NET32 dummy_subckt
XBJT_pin2 NET33 dummy_subckt
XBJT_pin3 NET34 dummy_subckt
XGround_pin0 NET34 dummy_subckt
XGround_pin0 NET44 dummy_subckt
.end
