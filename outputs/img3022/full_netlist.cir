* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin1 NET2 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XGround_pin0 NET9 dummy_subckt
.end
