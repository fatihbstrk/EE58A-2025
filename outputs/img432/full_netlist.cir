* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XCurrent_Source_pin0 NET17 dummy_subckt
XCurrent_Source_pin1 NET26 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XCurrent_Source_pin1 NET27 dummy_subckt
XGround_pin0 NET27 dummy_subckt
.end
