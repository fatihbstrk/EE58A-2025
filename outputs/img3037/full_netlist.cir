* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin3 NET18 dummy_subckt
XCapacitor_pin3 NET18 dummy_subckt
XAC_Source_pin0 NET18 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XAC_Source_pin1 NET20 dummy_subckt
.end
