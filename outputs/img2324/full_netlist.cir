* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XAC_Source_pin0 NET22 dummy_subckt
XAC_Source_pin1 NET24 dummy_subckt
.end
