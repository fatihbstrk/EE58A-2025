* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin3 NET7 dummy_subckt
XResistor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCapacitor_pin2 NET13 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XCapacitor_pin3 NET23 dummy_subckt
XMOSFET_pin3 NET23 dummy_subckt
XCapacitor_pin2 NET27 dummy_subckt
XMOSFET_pin2 NET27 dummy_subckt
XCapacitor_pin1 NET28 dummy_subckt
XCapacitor_pin1 NET32 dummy_subckt
XMOSFET_pin0 NET33 dummy_subckt
XMOSFET_pin0 NET34 dummy_subckt
XMOSFET_pin3 NET44 dummy_subckt
XMOSFET_pin2 NET47 dummy_subckt
XGround_pin0 NET53 dummy_subckt
XMOSFET_pin1 NET55 dummy_subckt
XMOSFET_pin1 NET56 dummy_subckt
XGround_pin3 NET60 dummy_subckt
XGround_pin2 NET61 dummy_subckt
XGround_pin1 NET62 dummy_subckt
.end
