* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET2 dummy_subckt
XBJT_pin2 NET3 dummy_subckt
XBJT_pin3 NET3 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin3 NET7 dummy_subckt
XCurrent_Source_pin0 NET8 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
.end
