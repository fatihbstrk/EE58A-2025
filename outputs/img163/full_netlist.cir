* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET4 dummy_subckt
XCurrent_Source_pin3 NET5 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XResistor_pin0 NET8 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XResistor_pin0 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XResistor_pin3 NET11 dummy_subckt
XResistor_pin3 NET12 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XBJT_pin2 NET16 dummy_subckt
XResistor_pin1 NET16 dummy_subckt
XResistor_pin1 NET19 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XResistor_pin0 NET25 dummy_subckt
XResistor_pin3 NET26 dummy_subckt
.end
