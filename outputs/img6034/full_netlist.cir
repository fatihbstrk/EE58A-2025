* Auto-generated SPICE netlist
.include technology_models.lib
XGround_pin1 NET1 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XMOSFET_pin2 NET25 dummy_subckt
XMOSFET_pin3 NET26 dummy_subckt
.end
