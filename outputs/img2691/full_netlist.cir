* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XAC_Source_pin1 NET10 dummy_subckt
XDC_Source_pin1 NET10 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XVoltage_Source_pin0 NET13 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XAC_Source_pin0 NET13 dummy_subckt
XAC_Source_pin0 NET13 dummy_subckt
XVoltage_Source_pin1 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XAC_Source_pin1 NET18 dummy_subckt
XCurrent_Source_pin1 NET18 dummy_subckt
.end
