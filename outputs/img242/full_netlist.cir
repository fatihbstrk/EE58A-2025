* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET2 dummy_subckt
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin3 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCurrent_Source_pin0 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XCapacitor_pin3 NET20 dummy_subckt
XCapacitor_pin1 NET23 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XGround_pin0 NET24 dummy_subckt
.end
