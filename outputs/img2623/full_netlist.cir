* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XResistor_pin3 NET3 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XGround_pin0 NET8 dummy_subckt
.end
