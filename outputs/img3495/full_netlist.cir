* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XInductor_pin0 NET7 dummy_subckt
XInductor_pin3 NET10 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XInductor_pin1 NET14 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XGround_pin0 NET31 dummy_subckt
XCurrent_Source_pin1 NET34 dummy_subckt
.end
