* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XBJT_pin2 NET10 dummy_subckt
XBJT_pin0 NET10 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XBJT_pin0 NET11 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XCurrent_Source_pin0 NET14 dummy_subckt
XResistor_pin1 NET14 dummy_subckt
XResistor_pin2 NET14 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XBJT_pin2 NET16 dummy_subckt
XBJT_pin3 NET17 dummy_subckt
XResistor_pin0 NET18 dummy_subckt
XResistor_pin0 NET19 dummy_subckt
XBJT_pin3 NET20 dummy_subckt
XBJT_pin3 NET21 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XResistor_pin3 NET25 dummy_subckt
XCurrent_Source_pin0 NET26 dummy_subckt
XCurrent_Source_pin0 NET26 dummy_subckt
XDC_Source_pin0 NET28 dummy_subckt
XGround_pin0 NET34 dummy_subckt
XCurrent_Source_pin1 NET35 dummy_subckt
XResistor_pin1 NET35 dummy_subckt
XDC_Source_pin1 NET35 dummy_subckt
XCurrent_Source_pin1 NET35 dummy_subckt
XCurrent_Source_pin1 NET35 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XGround_pin0 NET37 dummy_subckt
.end
