* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XResistor_pin0 NET9 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XBJT_pin2 NET18 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XBJT_pin2 NET19 dummy_subckt
XBJT_pin3 NET20 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
.end
