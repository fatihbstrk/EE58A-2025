* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XAC_Source_pin0 NET19 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XAC_Source_pin0 NET20 dummy_subckt
XAC_Source_pin0 NET25 dummy_subckt
XAC_Source_pin1 NET35 dummy_subckt
XGround_pin0 NET35 dummy_subckt
XAC_Source_pin1 NET36 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XAC_Source_pin1 NET40 dummy_subckt
XGround_pin0 NET40 dummy_subckt
XGround_pin1 NET41 dummy_subckt
.end
