* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin0 NET9 dummy_subckt
.end
