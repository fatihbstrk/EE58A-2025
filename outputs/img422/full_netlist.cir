* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XDC_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XCapacitor_pin0 NET8 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XMOSFET_pin2 NET21 dummy_subckt
XCurrent_Source_pin0 NET21 dummy_subckt
XMOSFET_pin3 NET25 dummy_subckt
XCurrent_Source_pin1 NET26 dummy_subckt
.end
