* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin0 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCapacitor_pin1 NET6 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
.end
