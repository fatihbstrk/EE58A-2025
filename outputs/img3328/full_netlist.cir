* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XResistor_pin0 NET6 dummy_subckt
XResistor_pin0 NET7 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XBJT_pin2 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XBJT_pin2 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XBJT_pin2 NET18 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
