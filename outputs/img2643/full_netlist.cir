* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin3 NET1 dummy_subckt
XCapacitor_pin3 NET1 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCurrent_Source_pin3 NET18 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XCapacitor_pin3 NET29 dummy_subckt
XGround_pin0 NET32 dummy_subckt
XGround_pin0 NET37 dummy_subckt
XGround_pin0 NET38 dummy_subckt
.end
