* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET4 dummy_subckt
XCurrent_Source_pin0 NET4 dummy_subckt
XCurrent_Source_pin2 NET11 dummy_subckt
XCurrent_Source_pin3 NET12 dummy_subckt
XCurrent_Source_pin2 NET13 dummy_subckt
XCurrent_Source_pin1 NET15 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
XBJT_pin0 NET22 dummy_subckt
XBJT_pin0 NET23 dummy_subckt
XBJT_pin2 NET32 dummy_subckt
XBJT_pin3 NET33 dummy_subckt
XCurrent_Source_pin0 NET41 dummy_subckt
XBJT_pin1 NET42 dummy_subckt
XBJT_pin1 NET43 dummy_subckt
XCurrent_Source_pin2 NET48 dummy_subckt
XGround_pin0 NET49 dummy_subckt
XCurrent_Source_pin1 NET49 dummy_subckt
XGround_pin2 NET50 dummy_subckt
XGround_pin3 NET51 dummy_subckt
XGround_pin1 NET52 dummy_subckt
.end
