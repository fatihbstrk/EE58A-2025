* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET1 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XCapacitor_pin1 NET8 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XBJT_pin2 NET9 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XBJT_pin2 NET12 dummy_subckt
XResistor_pin0 NET13 dummy_subckt
.end
