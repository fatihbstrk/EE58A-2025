* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XBJT_pin0 NET15 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XBJT_pin2 NET27 dummy_subckt
XGround_pin0 NET27 dummy_subckt
XBJT_pin3 NET28 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XBJT_pin3 NET29 dummy_subckt
XResistor_pin0 NET32 dummy_subckt
XCurrent_Source_pin0 NET32 dummy_subckt
XResistor_pin1 NET39 dummy_subckt
XCurrent_Source_pin1 NET39 dummy_subckt
.end
