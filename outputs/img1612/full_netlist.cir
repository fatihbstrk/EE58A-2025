* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
.end
