* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET8 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCurrent_Source_pin0 NET23 dummy_subckt
XCurrent_Source_pin1 NET28 dummy_subckt
XGround_pin0 NET28 dummy_subckt
.end
