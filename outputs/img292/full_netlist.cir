* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XResistor_pin2 NET15 dummy_subckt
XResistor_pin3 NET16 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
.end
