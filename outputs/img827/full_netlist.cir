* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET7 dummy_subckt
XResistor_pin1 NET14 dummy_subckt
XGround_pin2 NET31 dummy_subckt
.end
