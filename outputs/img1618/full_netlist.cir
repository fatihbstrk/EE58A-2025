* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XResistor_pin0 NET7 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XGround_pin0 NET12 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
XGround_pin0 NET14 dummy_subckt
.end
