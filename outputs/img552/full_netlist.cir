* Auto-generated SPICE netlist
.include technology_models.lib
XGround_pin0 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XBattery_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
.end
