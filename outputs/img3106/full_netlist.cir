* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XCapacitor_pin1 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XResistor_pin2 NET2 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XCapacitor_pin0 NET4 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin1 NET9 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XGround_pin0 NET11 dummy_subckt
XGround_pin0 NET12 dummy_subckt
XGround_pin0 NET13 dummy_subckt
.end
