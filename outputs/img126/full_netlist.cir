* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
