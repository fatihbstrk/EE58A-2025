* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET14 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XCurrent_Source_pin0 NET21 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCurrent_Source_pin1 NET23 dummy_subckt
.end
