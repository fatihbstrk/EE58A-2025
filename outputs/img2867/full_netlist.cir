* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XResistor_pin2 NET3 dummy_subckt
XCurrent_Source_pin1 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XCapacitor_pin0 NET4 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XGround_pin0 NET7 dummy_subckt
XCapacitor_pin1 NET8 dummy_subckt
XGround_pin0 NET8 dummy_subckt
.end
