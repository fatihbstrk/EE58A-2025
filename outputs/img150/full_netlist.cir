* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XBJT_pin3 NET11 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XResistor_pin0 NET14 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
.end
