* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin1 NET1 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
.end
