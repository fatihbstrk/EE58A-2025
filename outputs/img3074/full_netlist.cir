* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET1 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
XCapacitor_pin0 NET17 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XGround_pin0 NET20 dummy_subckt
.end
