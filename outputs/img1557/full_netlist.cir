* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET4 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XResistor_pin0 NET7 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XResistor_pin1 NET23 dummy_subckt
XBJT_pin2 NET32 dummy_subckt
XBJT_pin3 NET33 dummy_subckt
XBJT_pin3 NET34 dummy_subckt
XCurrent_Source_pin0 NET37 dummy_subckt
XCurrent_Source_pin1 NET41 dummy_subckt
XGround_pin0 NET41 dummy_subckt
.end
