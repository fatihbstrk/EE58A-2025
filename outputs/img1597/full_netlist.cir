* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin1 NET9 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCurrent_Source_pin0 NET22 dummy_subckt
XCurrent_Source_pin1 NET25 dummy_subckt
XGround_pin0 NET25 dummy_subckt
.end
