* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET2 dummy_subckt
XAC_Source_pin0 NET2 dummy_subckt
XAC_Source_pin3 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XCurrent_Source_pin0 NET5 dummy_subckt
XAC_Source_pin1 NET5 dummy_subckt
XCapacitor_pin0 NET10 dummy_subckt
XCapacitor_pin0 NET11 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XMOSFET_pin2 NET26 dummy_subckt
XCurrent_Source_pin3 NET32 dummy_subckt
XCurrent_Source_pin1 NET33 dummy_subckt
XGround_pin0 NET33 dummy_subckt
XGround_pin0 NET33 dummy_subckt
.end
