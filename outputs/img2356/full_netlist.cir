* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin0 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XResistor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin3 NET22 dummy_subckt
XCapacitor_pin1 NET29 dummy_subckt
.end
