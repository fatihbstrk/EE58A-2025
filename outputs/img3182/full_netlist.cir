* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XResistor_pin0 NET9 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XBJT_pin3 NET19 dummy_subckt
XBJT_pin2 NET20 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XBJT_pin2 NET21 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
