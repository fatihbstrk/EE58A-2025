* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET2 dummy_subckt
XDiode_pin0 NET2 dummy_subckt
XCapacitor_pin0 NET4 dummy_subckt
XDiode_pin1 NET5 dummy_subckt
XCapacitor_pin1 NET6 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XGround_pin0 NET11 dummy_subckt
.end
