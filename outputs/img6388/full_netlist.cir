* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XCapacitor_pin0 NET5 dummy_subckt
XResistor_pin0 NET6 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XResistor_pin1 NET16 dummy_subckt
XCapacitor_pin1 NET16 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCapacitor_pin1 NET17 dummy_subckt
XResistor_pin1 NET17 dummy_subckt
XMOSFET_pin3 NET24 dummy_subckt
XMOSFET_pin2 NET25 dummy_subckt
XCurrent_Source_pin0 NET28 dummy_subckt
XCurrent_Source_pin1 NET30 dummy_subckt
.end
