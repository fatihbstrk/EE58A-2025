* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin3 NET2 dummy_subckt
XBJT_pin0 NET2 dummy_subckt
XBJT_pin0 NET2 dummy_subckt
XBJT_pin2 NET2 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XBJT_pin2 NET10 dummy_subckt
XBJT_pin3 NET11 dummy_subckt
XResistor_pin0 NET12 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XResistor_pin0 NET18 dummy_subckt
XBJT_pin3 NET19 dummy_subckt
XResistor_pin1 NET20 dummy_subckt
XResistor_pin1 NET24 dummy_subckt
XResistor_pin1 NET24 dummy_subckt
XCapacitor_pin3 NET25 dummy_subckt
XCapacitor_pin3 NET26 dummy_subckt
XCapacitor_pin2 NET27 dummy_subckt
XCapacitor_pin2 NET28 dummy_subckt
XGround_pin0 NET32 dummy_subckt
XBJT_pin2 NET33 dummy_subckt
XBJT_pin3 NET33 dummy_subckt
XBJT_pin2 NET35 dummy_subckt
XBJT_pin3 NET39 dummy_subckt
XGround_pin0 NET41 dummy_subckt
XBJT_pin2 NET43 dummy_subckt
XBJT_pin2 NET44 dummy_subckt
XResistor_pin0 NET46 dummy_subckt
XResistor_pin3 NET47 dummy_subckt
.end
