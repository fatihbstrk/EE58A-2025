* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET21 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
XGround_pin1 NET21 dummy_subckt
XMOSFET_pin0 NET21 dummy_subckt
XMOSFET_pin3 NET21 dummy_subckt
XGround_pin0 NET31 dummy_subckt
XGround_pin0 NET32 dummy_subckt
XGround_pin0 NET33 dummy_subckt
.end
