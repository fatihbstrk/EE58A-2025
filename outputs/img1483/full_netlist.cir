* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XGround_pin0 NET18 dummy_subckt
.end
