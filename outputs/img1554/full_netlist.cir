* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET2 dummy_subckt
XBJT_pin2 NET12 dummy_subckt
XBJT_pin3 NET13 dummy_subckt
XCurrent_Source_pin0 NET17 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
