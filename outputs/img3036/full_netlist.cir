* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET1 dummy_subckt
XCapacitor_pin2 NET1 dummy_subckt
XCapacitor_pin2 NET1 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XResistor_pin2 NET4 dummy_subckt
XResistor_pin3 NET6 dummy_subckt
XResistor_pin3 NET9 dummy_subckt
XResistor_pin0 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XResistor_pin2 NET10 dummy_subckt
XResistor_pin0 NET10 dummy_subckt
XCurrent_Source_pin0 NET11 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
.end
