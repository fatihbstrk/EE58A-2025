* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
.end
