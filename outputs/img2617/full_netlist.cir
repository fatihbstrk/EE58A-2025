* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XCurrent_Source_pin0 NET16 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
XGround_pin1 NET20 dummy_subckt
.end
