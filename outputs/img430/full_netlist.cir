* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCapacitor_pin1 NET14 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCapacitor_pin1 NET15 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
XMOSFET_pin3 NET21 dummy_subckt
XCurrent_Source_pin0 NET22 dummy_subckt
XCapacitor_pin0 NET22 dummy_subckt
XCurrent_Source_pin0 NET23 dummy_subckt
XCurrent_Source_pin3 NET26 dummy_subckt
XCurrent_Source_pin3 NET26 dummy_subckt
XCapacitor_pin3 NET27 dummy_subckt
XCurrent_Source_pin3 NET28 dummy_subckt
XCapacitor_pin3 NET29 dummy_subckt
XCurrent_Source_pin3 NET30 dummy_subckt
XCapacitor_pin1 NET31 dummy_subckt
XGround_pin0 NET31 dummy_subckt
XCapacitor_pin1 NET32 dummy_subckt
XGround_pin0 NET32 dummy_subckt
XCurrent_Source_pin1 NET33 dummy_subckt
XCurrent_Source_pin1 NET33 dummy_subckt
XCurrent_Source_pin1 NET33 dummy_subckt
XCurrent_Source_pin1 NET33 dummy_subckt
.end
