* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET1 dummy_subckt
XCapacitor_pin2 NET1 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XResistor_pin0 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin2 NET20 dummy_subckt
XMOSFET_pin3 NET21 dummy_subckt
XCapacitor_pin3 NET21 dummy_subckt
XGround_pin0 NET25 dummy_subckt
XGround_pin0 NET26 dummy_subckt
.end
