* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XGround_pin1 NET8 dummy_subckt
XGround_pin1 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin1 NET10 dummy_subckt
XCurrent_Source_pin0 NET11 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XCapacitor_pin3 NET19 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCapacitor_pin1 NET26 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XCapacitor_pin1 NET29 dummy_subckt
XCapacitor_pin2 NET32 dummy_subckt
XGround_pin0 NET34 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XGround_pin0 NET37 dummy_subckt
XCapacitor_pin1 NET39 dummy_subckt
.end
