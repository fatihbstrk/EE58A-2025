* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XResistor_pin0 NET2 dummy_subckt
XResistor_pin0 NET2 dummy_subckt
XResistor_pin3 NET3 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XBJT_pin3 NET7 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XBJT_pin2 NET23 dummy_subckt
XBJT_pin3 NET24 dummy_subckt
XResistor_pin0 NET30 dummy_subckt
XResistor_pin0 NET30 dummy_subckt
XBJT_pin3 NET37 dummy_subckt
XBJT_pin3 NET38 dummy_subckt
XBJT_pin2 NET38 dummy_subckt
XBJT_pin3 NET39 dummy_subckt
XResistor_pin0 NET40 dummy_subckt
XResistor_pin3 NET41 dummy_subckt
XResistor_pin1 NET44 dummy_subckt
XResistor_pin1 NET44 dummy_subckt
XResistor_pin1 NET44 dummy_subckt
.end
