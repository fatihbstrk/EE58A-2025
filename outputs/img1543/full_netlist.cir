* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET4 dummy_subckt
XCurrent_Source_pin0 NET4 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin2 NET21 dummy_subckt
XCapacitor_pin3 NET22 dummy_subckt
XAC_Source_pin0 NET24 dummy_subckt
XGround_pin0 NET29 dummy_subckt
XAC_Source_pin1 NET29 dummy_subckt
.end
