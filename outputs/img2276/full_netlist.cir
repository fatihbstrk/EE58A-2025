* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XGround_pin0 NET12 dummy_subckt
.end
