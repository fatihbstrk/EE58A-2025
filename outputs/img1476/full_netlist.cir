* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XCurrent_Source_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XCurrent_Source_pin1 NET6 dummy_subckt
XBJT_pin0 NET6 dummy_subckt
XBJT_pin3 NET6 dummy_subckt
XGround_pin0 NET8 dummy_subckt
XGround_pin0 NET9 dummy_subckt
.end
