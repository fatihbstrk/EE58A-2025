* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin3 NET9 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin0 NET15 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XGround_pin0 NET24 dummy_subckt
XCapacitor_pin1 NET24 dummy_subckt
XCapacitor_pin2 NET25 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XCapacitor_pin3 NET28 dummy_subckt
XCapacitor_pin2 NET30 dummy_subckt
XCapacitor_pin2 NET31 dummy_subckt
XCapacitor_pin2 NET31 dummy_subckt
XCapacitor_pin3 NET32 dummy_subckt
XCapacitor_pin3 NET33 dummy_subckt
.end
