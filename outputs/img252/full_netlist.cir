* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XBJT_pin3 NET12 dummy_subckt
XBJT_pin2 NET13 dummy_subckt
XBJT_pin3 NET13 dummy_subckt
XBJT_pin3 NET14 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XBJT_pin3 NET23 dummy_subckt
XResistor_pin0 NET29 dummy_subckt
XResistor_pin0 NET29 dummy_subckt
XBJT_pin3 NET36 dummy_subckt
XBJT_pin2 NET37 dummy_subckt
XBJT_pin3 NET37 dummy_subckt
XResistor_pin1 NET42 dummy_subckt
XResistor_pin1 NET42 dummy_subckt
.end
