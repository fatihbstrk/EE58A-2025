* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XCapacitor_pin2 NET23 dummy_subckt
XCapacitor_pin3 NET24 dummy_subckt
XCapacitor_pin2 NET24 dummy_subckt
XGround_pin0 NET25 dummy_subckt
XGround_pin0 NET26 dummy_subckt
.end
