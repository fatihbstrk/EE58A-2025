* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET1 dummy_subckt
XMOSFET_pin2 NET1 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET13 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
