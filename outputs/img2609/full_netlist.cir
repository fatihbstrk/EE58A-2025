* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET9 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCurrent_Source_pin0 NET17 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
