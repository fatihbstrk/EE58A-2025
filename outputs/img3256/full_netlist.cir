* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XAC_Source_pin0 NET11 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XAC_Source_pin1 NET13 dummy_subckt
.end
