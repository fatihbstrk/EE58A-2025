* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XResistor_pin3 NET4 dummy_subckt
XResistor_pin2 NET7 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCurrent_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XMOSFET_pin3 NET25 dummy_subckt
XMOSFET_pin2 NET28 dummy_subckt
XGround_pin0 NET41 dummy_subckt
XGround_pin0 NET42 dummy_subckt
XMOSFET_pin3 NET48 dummy_subckt
XMOSFET_pin2 NET49 dummy_subckt
.end
