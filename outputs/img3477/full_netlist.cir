* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin2 NET10 dummy_subckt
XBJT_pin0 NET20 dummy_subckt
XBJT_pin2 NET20 dummy_subckt
XResistor_pin1 NET20 dummy_subckt
XResistor_pin0 NET21 dummy_subckt
XResistor_pin1 NET22 dummy_subckt
.end
