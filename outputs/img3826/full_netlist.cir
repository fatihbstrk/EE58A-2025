* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XGround_pin0 NET1 dummy_subckt
XGround_pin1 NET2 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XResistor_pin3 NET6 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
XResistor_pin2 NET22 dummy_subckt
XDC_Source_pin0 NET22 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XDC_Source_pin2 NET27 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XDC_Source_pin1 NET30 dummy_subckt
.end
