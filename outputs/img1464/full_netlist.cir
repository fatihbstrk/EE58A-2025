* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET4 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XCapacitor_pin1 NET20 dummy_subckt
XCapacitor_pin1 NET21 dummy_subckt
XResistor_pin1 NET27 dummy_subckt
XGround_pin0 NET27 dummy_subckt
.end
