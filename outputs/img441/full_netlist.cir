* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCurrent_Source_pin1 NET5 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XCapacitor_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET23 dummy_subckt
XCapacitor_pin2 NET23 dummy_subckt
XCapacitor_pin3 NET24 dummy_subckt
XCapacitor_pin3 NET24 dummy_subckt
.end
