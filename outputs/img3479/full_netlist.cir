* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET2 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XBattery_pin2 NET12 dummy_subckt
XMOSFET_pin3 NET18 dummy_subckt
XCapacitor_pin2 NET29 dummy_subckt
.end
