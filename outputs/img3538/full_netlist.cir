* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin2 NET10 dummy_subckt
XBJT_pin2 NET12 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XResistor_pin1 NET13 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XBJT_pin3 NET15 dummy_subckt
XBJT_pin1 NET16 dummy_subckt
XBJT_pin2 NET22 dummy_subckt
XResistor_pin0 NET22 dummy_subckt
XResistor_pin1 NET22 dummy_subckt
XResistor_pin0 NET22 dummy_subckt
XBJT_pin2 NET23 dummy_subckt
XResistor_pin1 NET23 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XResistor_pin0 NET26 dummy_subckt
XResistor_pin0 NET27 dummy_subckt
XResistor_pin0 NET30 dummy_subckt
XResistor_pin1 NET36 dummy_subckt
XGround_pin0 NET36 dummy_subckt
XResistor_pin0 NET40 dummy_subckt
XResistor_pin1 NET41 dummy_subckt
XResistor_pin1 NET41 dummy_subckt
XResistor_pin1 NET41 dummy_subckt
XResistor_pin1 NET41 dummy_subckt
XResistor_pin2 NET44 dummy_subckt
.end
