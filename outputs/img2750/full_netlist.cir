* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin0 NET5 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XCapacitor_pin1 NET14 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCurrent_Source_pin0 NET15 dummy_subckt
XCurrent_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
