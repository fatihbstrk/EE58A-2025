* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin2 NET15 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XGround_pin0 NET34 dummy_subckt
.end
