* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XResistor_pin0 NET8 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET10 dummy_subckt
XCurrent_Source_pin1 NET10 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XResistor_pin1 NET23 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
