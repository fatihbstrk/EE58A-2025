* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XCurrent_Source_pin1 NET15 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XGround_pin0 NET24 dummy_subckt
.end
