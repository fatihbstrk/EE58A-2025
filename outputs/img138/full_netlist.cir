* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin3 NET5 dummy_subckt
XBJT_pin2 NET5 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XAC_Source_pin0 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XDC_Source_pin0 NET21 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XAC_Source_pin1 NET30 dummy_subckt
XGround_pin0 NET33 dummy_subckt
XDC_Source_pin1 NET33 dummy_subckt
XGround_pin1 NET34 dummy_subckt
.end
