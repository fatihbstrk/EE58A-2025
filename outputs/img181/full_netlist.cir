* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin3 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET1 dummy_subckt
XBJT_pin2 NET1 dummy_subckt
XCurrent_Source_pin2 NET1 dummy_subckt
XCurrent_Source_pin3 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET1 dummy_subckt
XResistor_pin2 NET3 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XBJT_pin3 NET15 dummy_subckt
XResistor_pin0 NET16 dummy_subckt
XResistor_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
