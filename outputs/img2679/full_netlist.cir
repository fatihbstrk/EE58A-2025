* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XAC_Source_pin1 NET10 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
.end
