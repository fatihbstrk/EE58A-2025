* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET8 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XResistor_pin0 NET10 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XResistor_pin0 NET11 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin3 NET12 dummy_subckt
XResistor_pin2 NET13 dummy_subckt
XResistor_pin3 NET13 dummy_subckt
XResistor_pin2 NET13 dummy_subckt
XResistor_pin3 NET13 dummy_subckt
XResistor_pin1 NET27 dummy_subckt
XCapacitor_pin2 NET29 dummy_subckt
XResistor_pin0 NET31 dummy_subckt
XResistor_pin0 NET33 dummy_subckt
XBJT_pin3 NET34 dummy_subckt
XBJT_pin2 NET36 dummy_subckt
XResistor_pin1 NET36 dummy_subckt
XResistor_pin1 NET37 dummy_subckt
XBJT_pin3 NET41 dummy_subckt
XGround_pin0 NET44 dummy_subckt
XResistor_pin1 NET44 dummy_subckt
XGround_pin0 NET46 dummy_subckt
XGround_pin0 NET47 dummy_subckt
XBJT_pin3 NET48 dummy_subckt
XBJT_pin2 NET50 dummy_subckt
XGround_pin0 NET50 dummy_subckt
XGround_pin0 NET51 dummy_subckt
XBJT_pin3 NET51 dummy_subckt
XBJT_pin3 NET51 dummy_subckt
XGround_pin0 NET52 dummy_subckt
XGround_pin0 NET53 dummy_subckt
.end
