* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin1 NET3 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XBJT_pin2 NET7 dummy_subckt
XDiode_pin1 NET7 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XBJT_pin2 NET8 dummy_subckt
XBJT_pin3 NET8 dummy_subckt
XBJT_pin3 NET9 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XBJT_pin2 NET14 dummy_subckt
XDiode_pin0 NET14 dummy_subckt
XResistor_pin0 NET23 dummy_subckt
XDiode_pin3 NET24 dummy_subckt
XGround_pin0 NET27 dummy_subckt
XGround_pin0 NET28 dummy_subckt
XDiode_pin0 NET29 dummy_subckt
XDiode_pin1 NET29 dummy_subckt
XResistor_pin0 NET30 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XDiode_pin3 NET32 dummy_subckt
XResistor_pin3 NET33 dummy_subckt
XBJT_pin3 NET37 dummy_subckt
XResistor_pin1 NET39 dummy_subckt
XGround_pin0 NET39 dummy_subckt
.end
