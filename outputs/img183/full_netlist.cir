* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XResistor_pin0 NET23 dummy_subckt
XResistor_pin1 NET24 dummy_subckt
XGround_pin0 NET24 dummy_subckt
XResistor_pin3 NET25 dummy_subckt
.end
