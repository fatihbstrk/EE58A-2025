* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCurrent_Source_pin3 NET10 dummy_subckt
XCurrent_Source_pin1 NET15 dummy_subckt
XCurrent_Source_pin1 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
XMOSFET_pin2 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
XCapacitor_pin3 NET24 dummy_subckt
XMOSFET_pin3 NET24 dummy_subckt
XGround_pin0 NET29 dummy_subckt
XCapacitor_pin2 NET30 dummy_subckt
XMOSFET_pin2 NET31 dummy_subckt
XCapacitor_pin2 NET31 dummy_subckt
XMOSFET_pin3 NET32 dummy_subckt
XCapacitor_pin3 NET32 dummy_subckt
.end
