* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XGround_pin0 NET11 dummy_subckt
XGround_pin0 NET12 dummy_subckt
.end
