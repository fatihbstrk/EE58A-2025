* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
XGround_pin0 NET20 dummy_subckt
XMOSFET_pin3 NET22 dummy_subckt
XMOSFET_pin2 NET25 dummy_subckt
XMOSFET_pin3 NET26 dummy_subckt
XMOSFET_pin2 NET29 dummy_subckt
XGround_pin0 NET37 dummy_subckt
XGround_pin0 NET38 dummy_subckt
XMOSFET_pin2 NET44 dummy_subckt
.end
