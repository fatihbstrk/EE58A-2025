* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
.end
