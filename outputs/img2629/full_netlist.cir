* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XCapacitor_pin2 NET13 dummy_subckt
XCapacitor_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
