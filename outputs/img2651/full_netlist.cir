* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
