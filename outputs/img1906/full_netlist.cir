* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET12 dummy_subckt
XCurrent_Source_pin0 NET16 dummy_subckt
XCurrent_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
