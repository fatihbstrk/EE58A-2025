* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin1 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XCapacitor_pin3 NET2 dummy_subckt
XAC_Source_pin0 NET2 dummy_subckt
XAC_Source_pin1 NET2 dummy_subckt
XCapacitor_pin2 NET2 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin2 NET12 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCurrent_Source_pin3 NET25 dummy_subckt
XAC_Source_pin3 NET26 dummy_subckt
XCapacitor_pin2 NET27 dummy_subckt
.end
