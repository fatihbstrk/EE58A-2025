* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET8 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XResistor_pin0 NET16 dummy_subckt
XBJT_pin3 NET19 dummy_subckt
XBJT_pin2 NET20 dummy_subckt
XResistor_pin1 NET20 dummy_subckt
XGround_pin0 NET20 dummy_subckt
.end
