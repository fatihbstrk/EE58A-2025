* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XMOSFET_pin3 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XCapacitor_pin2 NET19 dummy_subckt
XGround_pin0 NET25 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XGround_pin3 NET27 dummy_subckt
.end
