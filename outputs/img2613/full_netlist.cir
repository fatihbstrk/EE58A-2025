* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XGround_pin0 NET7 dummy_subckt
.end
