* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XResistor_pin1 NET4 dummy_subckt
XCapacitor_pin3 NET4 dummy_subckt
XCapacitor_pin0 NET6 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCapacitor_pin0 NET7 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XCurrent_Source_pin0 NET10 dummy_subckt
XCapacitor_pin1 NET13 dummy_subckt
XCapacitor_pin1 NET13 dummy_subckt
XCurrent_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XCurrent_Source_pin1 NET18 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
XGround_pin0 NET19 dummy_subckt
.end
