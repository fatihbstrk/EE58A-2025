* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin2 NET16 dummy_subckt
XAC_Source_pin3 NET20 dummy_subckt
XAC_Source_pin1 NET22 dummy_subckt
XCapacitor_pin2 NET26 dummy_subckt
XMOSFET_pin3 NET27 dummy_subckt
XCapacitor_pin3 NET27 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XCapacitor_pin2 NET33 dummy_subckt
.end
