* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET3 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XAC_Source_pin3 NET4 dummy_subckt
XAC_Source_pin1 NET8 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
.end
