* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XResistor_pin1 NET3 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XAC_Source_pin0 NET7 dummy_subckt
XAC_Source_pin0 NET7 dummy_subckt
XMOSFET_pin3 NET9 dummy_subckt
XAC_Source_pin0 NET9 dummy_subckt
XCurrent_Source_pin0 NET10 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XAC_Source_pin1 NET14 dummy_subckt
XAC_Source_pin1 NET14 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XAC_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XCurrent_Source_pin1 NET19 dummy_subckt
.end
