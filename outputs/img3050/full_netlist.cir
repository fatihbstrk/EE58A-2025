* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET3 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XCapacitor_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin3 NET8 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XResistor_pin1 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XCapacitor_pin3 NET11 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XGround_pin0 NET16 dummy_subckt
.end
