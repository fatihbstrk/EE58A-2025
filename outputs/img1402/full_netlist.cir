* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin0 NET7 dummy_subckt
XMOSFET_pin0 NET8 dummy_subckt
XMOSFET_pin3 NET15 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XMOSFET_pin1 NET28 dummy_subckt
XCurrent_Source_pin0 NET37 dummy_subckt
XCapacitor_pin2 NET54 dummy_subckt
XCurrent_Source_pin1 NET54 dummy_subckt
XGround_pin0 NET54 dummy_subckt
XMOSFET_pin3 NET61 dummy_subckt
XMOSFET_pin2 NET66 dummy_subckt
XCapacitor_pin3 NET66 dummy_subckt
XGround_pin0 NET67 dummy_subckt
XCapacitor_pin1 NET72 dummy_subckt
XMOSFET_pin1 NET74 dummy_subckt
XGround_pin0 NET74 dummy_subckt
XGround_pin3 NET79 dummy_subckt
XGround_pin3 NET82 dummy_subckt
XGround_pin2 NET87 dummy_subckt
XGround_pin3 NET91 dummy_subckt
XGround_pin1 NET96 dummy_subckt
XGround_pin1 NET97 dummy_subckt
XGround_pin1 NET98 dummy_subckt
.end
