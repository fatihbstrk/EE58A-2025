* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET2 dummy_subckt
XMOSFET_pin3 NET2 dummy_subckt
XCurrent_Source_pin0 NET2 dummy_subckt
XCurrent_Source_pin1 NET4 dummy_subckt
XGround_pin0 NET4 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XCapacitor_pin2 NET5 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XGround_pin0 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
.end
