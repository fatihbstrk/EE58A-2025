* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin1 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XCurrent_Source_pin2 NET10 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin2 NET15 dummy_subckt
XMOSFET_pin3 NET18 dummy_subckt
XMOSFET_pin3 NET19 dummy_subckt
XCapacitor_pin2 NET21 dummy_subckt
XMOSFET_pin3 NET30 dummy_subckt
XMOSFET_pin3 NET33 dummy_subckt
.end
