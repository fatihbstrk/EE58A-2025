* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET2 dummy_subckt
XMOSFET_pin2 NET2 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XCapacitor_pin3 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XCurrent_Source_pin0 NET12 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XCurrent_Source_pin1 NET13 dummy_subckt
.end
