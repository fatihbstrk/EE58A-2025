* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET4 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XCapacitor_pin2 NET6 dummy_subckt
XResistor_pin0 NET10 dummy_subckt
XCurrent_Source_pin0 NET10 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XCurrent_Source_pin1 NET16 dummy_subckt
XCurrent_Source_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
