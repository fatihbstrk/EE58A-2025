* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XBJT_pin3 NET6 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XResistor_pin1 NET6 dummy_subckt
XBattery_pin0 NET10 dummy_subckt
XBattery_pin0 NET10 dummy_subckt
.end
