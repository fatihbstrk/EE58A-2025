* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET4 dummy_subckt
XGround_pin0 NET4 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XResistor_pin0 NET8 dummy_subckt
XResistor_pin1 NET12 dummy_subckt
XGround_pin0 NET12 dummy_subckt
.end
