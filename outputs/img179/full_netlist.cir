* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET5 dummy_subckt
XBJT_pin2 NET10 dummy_subckt
XBJT_pin3 NET10 dummy_subckt
XResistor_pin1 NET10 dummy_subckt
XBJT_pin2 NET11 dummy_subckt
XResistor_pin0 NET12 dummy_subckt
XBJT_pin3 NET13 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XResistor_pin1 NET16 dummy_subckt
XBJT_pin2 NET17 dummy_subckt
.end
