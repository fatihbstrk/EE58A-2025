* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XMOSFET_pin2 NET10 dummy_subckt
XResistor_pin0 NET10 dummy_subckt
XCurrent_Source_pin2 NET10 dummy_subckt
XCurrent_Source_pin3 NET10 dummy_subckt
XCurrent_Source_pin2 NET10 dummy_subckt
XCurrent_Source_pin3 NET10 dummy_subckt
XMOSFET_pin2 NET11 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XMOSFET_pin3 NET16 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XMOSFET_pin3 NET23 dummy_subckt
XResistor_pin3 NET25 dummy_subckt
XMOSFET_pin2 NET26 dummy_subckt
XCapacitor_pin3 NET26 dummy_subckt
XMOSFET_pin3 NET26 dummy_subckt
XResistor_pin1 NET30 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XMOSFET_pin2 NET36 dummy_subckt
XMOSFET_pin3 NET37 dummy_subckt
.end
