* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin2 NET6 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XMOSFET_pin0 NET16 dummy_subckt
XMOSFET_pin2 NET26 dummy_subckt
XMOSFET_pin0 NET33 dummy_subckt
XMOSFET_pin2 NET40 dummy_subckt
XGround_pin0 NET43 dummy_subckt
XMOSFET_pin1 NET45 dummy_subckt
XGround_pin2 NET48 dummy_subckt
XGround_pin3 NET49 dummy_subckt
.end
