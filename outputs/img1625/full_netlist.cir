* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XMOSFET_pin3 NET20 dummy_subckt
.end
