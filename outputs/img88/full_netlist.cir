* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET5 dummy_subckt
XResistor_pin0 NET5 dummy_subckt
XResistor_pin1 NET8 dummy_subckt
XResistor_pin1 NET9 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XGround_pin0 NET17 dummy_subckt
XBJT_pin2 NET20 dummy_subckt
XBJT_pin3 NET20 dummy_subckt
XAC_Source_pin0 NET20 dummy_subckt
XResistor_pin0 NET23 dummy_subckt
XCurrent_Source_pin0 NET23 dummy_subckt
XGround_pin0 NET26 dummy_subckt
XAC_Source_pin1 NET26 dummy_subckt
XResistor_pin1 NET28 dummy_subckt
XCurrent_Source_pin1 NET28 dummy_subckt
XGround_pin0 NET28 dummy_subckt
.end
