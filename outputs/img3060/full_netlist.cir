* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin1 NET1 dummy_subckt
XResistor_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET4 dummy_subckt
XResistor_pin0 NET4 dummy_subckt
XResistor_pin1 NET15 dummy_subckt
XGround_pin0 NET15 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XResistor_pin1 NET16 dummy_subckt
XCurrent_Source_pin1 NET18 dummy_subckt
XGround_pin0 NET18 dummy_subckt
XGround_pin0 NET19 dummy_subckt
.end
