* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin3 NET10 dummy_subckt
XCapacitor_pin2 NET11 dummy_subckt
XMOSFET_pin2 NET21 dummy_subckt
XMOSFET_pin3 NET22 dummy_subckt
XResistor_pin2 NET28 dummy_subckt
XCurrent_Source_pin0 NET28 dummy_subckt
XResistor_pin3 NET29 dummy_subckt
XCurrent_Source_pin0 NET29 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XCurrent_Source_pin1 NET30 dummy_subckt
XGround_pin0 NET31 dummy_subckt
XCurrent_Source_pin1 NET31 dummy_subckt
.end
