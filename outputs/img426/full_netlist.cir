* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET4 dummy_subckt
XCapacitor_pin2 NET4 dummy_subckt
XMOSFET_pin3 NET5 dummy_subckt
XCapacitor_pin3 NET5 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XCurrent_Source_pin0 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XCapacitor_pin0 NET8 dummy_subckt
XMOSFET_pin3 NET11 dummy_subckt
XMOSFET_pin2 NET13 dummy_subckt
XMOSFET_pin2 NET14 dummy_subckt
XCurrent_Source_pin1 NET14 dummy_subckt
XCapacitor_pin2 NET14 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin3 NET15 dummy_subckt
XCapacitor_pin0 NET18 dummy_subckt
XCapacitor_pin1 NET21 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XMOSFET_pin2 NET22 dummy_subckt
XResistor_pin2 NET22 dummy_subckt
XResistor_pin3 NET23 dummy_subckt
XCapacitor_pin3 NET28 dummy_subckt
XCapacitor_pin3 NET28 dummy_subckt
XMOSFET_pin3 NET29 dummy_subckt
.end
