* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET1 dummy_subckt
XResistor_pin1 NET2 dummy_subckt
XCapacitor_pin0 NET3 dummy_subckt
XAC_Source_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XGround_pin0 NET6 dummy_subckt
XMOSFET_pin2 NET9 dummy_subckt
XCapacitor_pin1 NET9 dummy_subckt
XCapacitor_pin0 NET9 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XAC_Source_pin1 NET10 dummy_subckt
XGround_pin0 NET14 dummy_subckt
XCapacitor_pin1 NET17 dummy_subckt
XGround_pin0 NET17 dummy_subckt
.end
