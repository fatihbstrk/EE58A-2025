* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin0 NET3 dummy_subckt
XCurrent_Source_pin3 NET4 dummy_subckt
XCurrent_Source_pin3 NET5 dummy_subckt
XCurrent_Source_pin3 NET6 dummy_subckt
XCurrent_Source_pin3 NET7 dummy_subckt
XCapacitor_pin3 NET8 dummy_subckt
XResistor_pin2 NET8 dummy_subckt
XCurrent_Source_pin0 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCurrent_Source_pin1 NET8 dummy_subckt
XCapacitor_pin2 NET9 dummy_subckt
XCurrent_Source_pin1 NET9 dummy_subckt
XCapacitor_pin3 NET16 dummy_subckt
XCapacitor_pin2 NET21 dummy_subckt
XResistor_pin3 NET25 dummy_subckt
XMOSFET_pin3 NET25 dummy_subckt
XCurrent_Source_pin0 NET25 dummy_subckt
XResistor_pin0 NET28 dummy_subckt
XResistor_pin0 NET29 dummy_subckt
XCapacitor_pin3 NET30 dummy_subckt
XResistor_pin2 NET30 dummy_subckt
XCapacitor_pin2 NET31 dummy_subckt
XResistor_pin3 NET31 dummy_subckt
XMOSFET_pin2 NET32 dummy_subckt
XCurrent_Source_pin3 NET34 dummy_subckt
XCurrent_Source_pin3 NET35 dummy_subckt
.end
