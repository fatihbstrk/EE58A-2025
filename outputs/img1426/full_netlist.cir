* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET9 dummy_subckt
.end
