* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XCapacitor_pin3 NET14 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XCapacitor_pin2 NET18 dummy_subckt
XDiode_pin0 NET19 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XCapacitor_pin3 NET22 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XDiode_pin1 NET30 dummy_subckt
XCapacitor_pin3 NET32 dummy_subckt
XCapacitor_pin3 NET33 dummy_subckt
XCapacitor_pin3 NET33 dummy_subckt
XGround_pin0 NET34 dummy_subckt
XCapacitor_pin2 NET34 dummy_subckt
XGround_pin0 NET35 dummy_subckt
XMOSFET_pin2 NET35 dummy_subckt
XCapacitor_pin2 NET35 dummy_subckt
XCapacitor_pin3 NET36 dummy_subckt
XCapacitor_pin3 NET36 dummy_subckt
XGround_pin0 NET37 dummy_subckt
XCapacitor_pin2 NET37 dummy_subckt
XCapacitor_pin2 NET37 dummy_subckt
XGround_pin0 NET39 dummy_subckt
XCapacitor_pin2 NET39 dummy_subckt
XGround_pin0 NET40 dummy_subckt
XGround_pin0 NET41 dummy_subckt
.end
