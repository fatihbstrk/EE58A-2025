* Auto-generated SPICE netlist
.include technology_models.lib
XAC_Source_pin0 NET1 dummy_subckt
XAC_Source_pin1 NET5 dummy_subckt
XMOSFET_pin2 NET16 dummy_subckt
XMOSFET_pin2 NET17 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin3 NET18 dummy_subckt
XMOSFET_pin2 NET18 dummy_subckt
XMOSFET_pin3 NET19 dummy_subckt
XAC_Source_pin0 NET28 dummy_subckt
XAC_Source_pin1 NET29 dummy_subckt
.end
