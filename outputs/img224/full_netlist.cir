* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET4 dummy_subckt
XResistor_pin3 NET5 dummy_subckt
XResistor_pin3 NET6 dummy_subckt
XResistor_pin1 NET7 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XBJT_pin3 NET16 dummy_subckt
XCurrent_Source_pin0 NET18 dummy_subckt
XCurrent_Source_pin3 NET19 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
.end
