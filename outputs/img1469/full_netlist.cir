* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET10 dummy_subckt
XCapacitor_pin2 NET17 dummy_subckt
XGround_pin0 NET20 dummy_subckt
.end
