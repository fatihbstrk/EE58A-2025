* Auto-generated SPICE netlist
.include technology_models.lib
XCurrent_Source_pin0 NET1 dummy_subckt
XCurrent_Source_pin1 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XCapacitor_pin2 NET7 dummy_subckt
XGround_pin0 NET44 dummy_subckt
XGround_pin0 NET52 dummy_subckt
.end
