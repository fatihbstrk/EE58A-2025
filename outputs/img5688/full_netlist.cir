* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET4 dummy_subckt
XGround_pin0 NET8 dummy_subckt
.end
