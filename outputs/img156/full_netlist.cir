* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin3 NET5 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET6 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XMOSFET_pin2 NET25 dummy_subckt
XMOSFET_pin3 NET25 dummy_subckt
XResistor_pin0 NET25 dummy_subckt
XMOSFET_pin3 NET27 dummy_subckt
XResistor_pin1 NET30 dummy_subckt
XGround_pin0 NET30 dummy_subckt
XResistor_pin3 NET31 dummy_subckt
.end
