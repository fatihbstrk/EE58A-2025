* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin3 NET6 dummy_subckt
XCurrent_Source_pin0 NET6 dummy_subckt
XBJT_pin2 NET6 dummy_subckt
XBJT_pin0 NET11 dummy_subckt
XBJT_pin2 NET15 dummy_subckt
XCurrent_Source_pin1 NET16 dummy_subckt
XGround_pin0 NET16 dummy_subckt
XGround_pin0 NET19 dummy_subckt
XGround_pin0 NET21 dummy_subckt
.end
