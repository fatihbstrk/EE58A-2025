* Auto-generated SPICE netlist
.include technology_models.lib
XResistor_pin0 NET3 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XMOSFET_pin2 NET4 dummy_subckt
XGround_pin0 NET4 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XResistor_pin1 NET5 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XGround_pin0 NET10 dummy_subckt
XGround_pin0 NET15 dummy_subckt
.end
