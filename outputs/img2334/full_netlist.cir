* Auto-generated SPICE netlist
.include technology_models.lib
XMOSFET_pin2 NET6 dummy_subckt
XMOSFET_pin3 NET7 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XAC_Source_pin0 NET15 dummy_subckt
XAC_Source_pin0 NET15 dummy_subckt
XAC_Source_pin1 NET18 dummy_subckt
XAC_Source_pin1 NET18 dummy_subckt
.end
