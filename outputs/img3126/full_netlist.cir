* Auto-generated SPICE netlist
.include technology_models.lib
XCapacitor_pin2 NET2 dummy_subckt
XMOSFET_pin2 NET3 dummy_subckt
XCapacitor_pin3 NET3 dummy_subckt
XMOSFET_pin3 NET4 dummy_subckt
XMOSFET_pin2 NET5 dummy_subckt
XMOSFET_pin2 NET7 dummy_subckt
XMOSFET_pin2 NET12 dummy_subckt
XMOSFET_pin3 NET13 dummy_subckt
XCurrent_Source_pin0 NET13 dummy_subckt
XMOSFET_pin3 NET17 dummy_subckt
XMOSFET_pin2 NET19 dummy_subckt
XMOSFET_pin2 NET20 dummy_subckt
XGround_pin0 NET21 dummy_subckt
XCurrent_Source_pin1 NET21 dummy_subckt
XGround_pin0 NET22 dummy_subckt
XGround_pin0 NET23 dummy_subckt
.end
