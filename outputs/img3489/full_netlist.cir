* Auto-generated SPICE netlist
.include technology_models.lib
XBJT_pin0 NET2 dummy_subckt
XDC_Source_pin0 NET5 dummy_subckt
XBJT_pin2 NET5 dummy_subckt
XBJT_pin3 NET5 dummy_subckt
XDC_Source_pin3 NET10 dummy_subckt
XDC_Source_pin1 NET13 dummy_subckt
XGround_pin0 NET13 dummy_subckt
XGround_pin0 NET25 dummy_subckt
.end
